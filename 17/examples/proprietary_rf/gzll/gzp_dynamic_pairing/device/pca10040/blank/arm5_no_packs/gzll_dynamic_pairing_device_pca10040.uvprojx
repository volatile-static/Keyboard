# Keil uVision project gzll_dynamic_pairing_device_pca10040.uvprojx, settings and files
target nrf52832_xxaa (ARM-ADS)
  device: nRF52832_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack_NordicLicense.8.27.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(64000000) ELITTLE
  output: nrf52832_xxaa +hex
  c flags: Optim=4 OneElfS=1 uC99=1
  c define: APP_TIMER_V2 APP_TIMER_V2_RTC1_ENABLED BOARD_PCA10040 BSP_SIMPLE CONFIG_GPIO_AS_PINRESET FLOAT_ABI_HARD GAZELL_ALTERNATIVE_RESOURCES GAZELL_PRESENT NRF52 NRF52832_XXAA NRF52_PAN_74 USE_SD_HW_RESOURCES __HEAP_SIZE=8192 __STACK_SIZE=8192
  c misc: --reduce_paths
  c include: ..\..\..\config;..\..\..\..\..\..\..\..\components;..\..\..\..\..\..\..\..\components\boards;..\..\..\..\..\..\..\..\components\drivers_nrf\nrf_soc_nosd;..\..\..\..\..\..\..\..\components\libraries\atomic;..\..\..\..\..\..\..\..\components\libraries\atomic_fifo;..\..\..\..\..\..\..\..\components\libraries\balloc;..\..\..\..\..\..\..\..\components\libraries\bsp;..\..\..\..\..\..\..\..\components\libraries\button;..\..\..\..\..\..\..\..\components\libraries\delay;..\..\..\..\..\..\..\..\components\libraries\experimental_section_vars;..\..\..\..\..\..\..\..\components\libraries\log;..\..\..\..\..\..\..\..\components\libraries\log\src;..\..\..\..\..\..\..\..\components\libraries\memobj;..\..\..\..\..\..\..\..\components\libraries\ringbuf;..\..\..\..\..\..\..\..\components\libraries\scheduler;..\..\..\..\..\..\..\..\components\libraries\sortlist;..\..\..\..\..\..\..\..\components\libraries\strerror;..\..\..\..\..\..\..\..\components\libraries\timer;..\..\..\..\..\..\..\..\components\libraries\util;..\..\..\..\..\..\..\..\components\proprietary_rf\gzll;..\..\..;..\..\..\..\..\..\..\..\external\fprintf;..\..\..\..\..\..\..\..\external\segger_rtt;..\..\..\..\..\..\..\..\integration\nrfx;..\..\..\..\..\..\..\..\integration\nrfx\legacy;..\..\..\..\..\..\..\..\modules\nrfx;..\..\..\..\..\..\..\..\modules\nrfx\drivers\include;..\..\..\..\..\..\..\..\modules\nrfx\hal;..\..\..\..\..\..\..\..\modules\nrfx\mdk;..\config
  asm define: as above
  asm misc: --cpreproc_opts=-DAPP_TIMER_V2,-DAPP_TIMER_V2_RTC1_ENABLED,-DBOARD_PCA10040,-DBSP_SIMPLE,-DCONFIG_GPIO_AS_PINRESET,-DFLOAT_ABI_HARD,-DGAZELL_ALTERNATIVE_RESOURCES,-DGAZELL_PRESENT,-DNRF52,-DNRF52832_XXAA,-DNRF52_PAN_74,-DUSE_SD_HW_RESOURCES,-D__HEAP_SIZE=8192,-D__STACK_SIZE=8192
  asm include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  link misc: --diag_suppress 6330
  group Application
    ../../../: main.c
    ../config/: sdk_config.h
  group Board Definition
    ../../../../../../../../components/boards/: boards.c
  group Board Support
    ../../../../../../../../components/libraries/bsp/: bsp.c
  group nRF_Drivers
    ../../../../../../../../integration/nrfx/legacy/: nrf_drv_uart.c
    ../../../../../../../../modules/nrfx/hal/: nrf_ecb.c nrf_nvmc.c
    ../../../../../../../../modules/nrfx/soc/: nrfx_atomic.c
    ../../../../../../../../modules/nrfx/drivers/src/: nrfx_gpiote.c nrfx_uart.c nrfx_uarte.c
    ../../../../../../../../modules/nrfx/drivers/src/prs/: nrfx_prs.c
  group nRF_Libraries
    ../../../../../../../../components/libraries/button/: app_button.c
    ../../../../../../../../components/libraries/util/: app_error.c app_error_handler_keil.c app_error_weak.c app_util_platform.c nrf_assert.c
    ../../../../../../../../components/libraries/scheduler/: app_scheduler.c
    ../../../../../../../../components/libraries/timer/: app_timer2.c drv_rtc.c
    ../../../../../../../../components/libraries/atomic_fifo/: nrf_atfifo.c
    ../../../../../../../../components/libraries/atomic/: nrf_atomic.c
    ../../../../../../../../components/libraries/balloc/: nrf_balloc.c
    ../../../../../../../../external/fprintf/: nrf_fprintf.c nrf_fprintf_format.c
    ../../../../../../../../components/libraries/memobj/: nrf_memobj.c
    ../../../../../../../../components/libraries/ringbuf/: nrf_ringbuf.c
    ../../../../../../../../components/libraries/sortlist/: nrf_sortlist.c
    ../../../../../../../../components/libraries/strerror/: nrf_strerror.c
  group nRF_Log
    ../../../../../../../../components/libraries/log/src/: nrf_log_backend_rtt.c nrf_log_backend_serial.c nrf_log_backend_uart.c nrf_log_default_backends.c nrf_log_frontend.c nrf_log_str_formatter.c
  group nRF_Properitary_RF
    ../../../../../../../../components/proprietary_rf/gzll/arm/: gzll_nrf52_sd_resources_arm.lib
    ../../../../../../../../components/proprietary_rf/gzll/: nrf_gzp.c nrf_gzp_device.c
  group nRF_Segger_RTT
    ../../../../../../../../external/segger_rtt/: SEGGER_RTT.c SEGGER_RTT_Syscalls_KEIL.c SEGGER_RTT_printf.c
software components: CMSIS:CORE 4.3.0, Device:Startup 8.27.0

# Keil uVision project iot_socket_tcp_client_pca10040_s132.uvprojx, settings and files
target nrf52832_xxaa (ARM-ADS)
  device: nRF52832_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack_NordicLicense.8.27.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(64000000) ELITTLE
  output: nrf52832_xxaa +hex
  c flags: Optim=4 OneElfS=1 uC99=1 wLevel=1
  c define: APP_TIMER_V2 APP_TIMER_V2_RTC1_ENABLED BLE_STACK_SUPPORT_REQD BOARD_PCA10040 CONFIG_GPIO_AS_PINRESET FLOAT_ABI_HARD LWIP_DONT_PROVIDE_BYTEORDER_FUNCTIONS NRF52 NRF52832_XXAA NRF52_PAN_74 NRF_SD_BLE_API_VERSION=7 RETARGET_ENABLED=1 S132 SDK_MUTEX_ENABLE SOFTDEVICE_PRESENT __HEAP_SIZE=0 __STACK_SIZE=8192
  c misc: --reduce_paths
  c include: ..\..\..\config;..\..\..\..\..\..\..\..\components\iot\errno;..\..\..\..\..\..\..\..\components;..\..\..\..\..\..\..\..\components\ble\ble_advertising;..\..\..\..\..\..\..\..\components\ble\ble_dtm;..\..\..\..\..\..\..\..\components\ble\ble_racp;..\..\..\..\..\..\..\..\components\ble\ble_services\ble_ancs_c;..\..\..\..\..\..\..\..\components\ble\ble_services\ble_ans_c;..\..\..\..\..\..\..\..\components\ble\ble_services\ble_bas;..\..\..\..\..\..\..\..\components\ble\ble_services\ble_bas_c;..\..\..\..\..\..\..\..\components\ble\ble_services\ble_cscs;..\..\..\..\..\..\..\..\components\ble\ble_services\ble_cts_c;..\..\..\..\..\..\..\..\components\ble\ble_services\ble_dfu;..\..\..\..\..\..\..\..\components\ble\ble_services\ble_dis;..\..\..\..\..\..\..\..\components\ble\ble_services\ble_gls;..\..\..\..\..\..\..\..\components\ble\ble_services\ble_hids;..\..\..\..\..\..\..\..\components\ble\ble_services\ble_hrs;..\..\..\..\..\..\..\..\components\ble\ble_services\ble_hrs_c;..\..\..\..\..\..\..\..\components\ble\ble_services\ble_hts;..\..\..\..\..\..\..\..\components\ble\ble_services\ble_ias;..\..\..\..\..\..\..\..\components\ble\ble_services\ble_ias_c;..\..\..\..\..\..\..\..\components\ble\ble_services\ble_ipsp;..\..\..\..\..\..\..\..\components\ble\ble_services\ble_lbs;..\..\..\..\..\..\..\..\components\ble\ble_services\ble_lbs_c;..\..\..\..\..\..\..\..\components\ble\ble_services\ble_lls;..\..\..\..\..\..\..\..\components\ble\ble_services\ble_nus;..\..\..\..\..\..\..\..\components\ble\ble_services\ble_nus_c;..\..\..\..\..\..\..\..\components\ble\ble_services\ble_rscs;..\..\..\..\..\..\..\..\components\ble\ble_services\ble_rscs_c;..\..\..\..\..\..\..\..\components\ble\ble_services\ble_tps;..\..\..\..\..\..\..\..\components\ble\common;..\..\..\..\..\..\..\..\components\ble\nrf_ble_qwr;..\..\..\..\..\..\..\..\components\ble\peer_manager;..\..\..\..\..\..\..\..\components\boards;..\..\..\..\..\..\..\..\components\iot\ble_6lowpan;..\..\..\..\..\..\..\..\components\iot\common;..\..\..\..\..\..\..\..\components\iot\context_manager;..\..\..\..\..\..\..\..\components\iot\ipv6_parse;..\..\..\..\..\..\..\..\components\iot\medium;..\..\..\..\..\..\..\..\components\iot\socket\api;..\..\..\..\..\..\..\..\components\iot\socket\common;..\..\..\..\..\..\..\..\components\iot\socket\config\medium;..\..\..\..\..\..\..\..\components\iot\socket\libraries\fifo;..\..\..\..\..\..\..\..\components\iot\socket\libraries\mbuf;..\..\..\..\..\..\..\..\components\iot\socket\libraries\portdb;..\..\..\..\..\..\..\..\components\iot\socket\platform\ble;..\..\..\..\..\..\..\..\components\iot\socket\transport\lwip;..\..\..\..\..\..\..\..\components\libraries\atomic;..\..\..\..\..\..\..\..\components\libraries\atomic_fifo;..\..\..\..\..\..\..\..\components\libraries\balloc;..\..\..\..\..\..\..\..\components\libraries\bootloader\ble_dfu;..\..\..\..\..\..\..\..\components\libraries\bsp;..\..\..\..\..\..\..\..\components\libraries\button;..\..\..\..\..\..\..\..\components\libraries\cli;..\..\..\..\..\..\..\..\components\libraries\crc16;..\..\..\..\..\..\..\..\components\libraries\crc32;..\..\..\..\..\..\..\..\components\libraries\crypto;..\..\..\..\..\..\..\..\components\libraries\csense;..\..\..\..\..\..\..\..\components\libraries\csense_drv;..\..\..\..\..\..\..\..\components\libraries\delay;..\..\..\..\..\..\..\..\components\libraries\ecc;..\..\..\..\..\..\..\..\components\libraries\experimental_section_vars;..\..\..\..\..\..\..\..\components\libraries\experimental_task_manager;..\..\..\..\..\..\..\..\components\libraries\fds;..\..\..\..\..\..\..\..\components\libraries\fstorage;..\..\..\..\..\..\..\..\components\libraries\gfx;..\..\..\..\..\..\..\..\components\libraries\gpiote;..\..\..\..\..\..\..\..\components\libraries\hardfault;..\..\..\..\..\..\..\..\components\libraries\hci;..\..\..\..\..\..\..\..\components\libraries\led_softblink;..\..\..\..\..\..\..\..\components\libraries\log;..\..\..\..\..\..\..\..\components\libraries\log\src;..\..\..\..\..\..\..\..\components\libraries\low_power_pwm;..\..\..\..\..\..\..\..\components\libraries\mem_manager;..\..\..\..\..\..\..\..\components\libraries\memobj;..\..\..\..\..\..\..\..\components\libraries\mpu;..\..\..\..\..\..\..\..\components\libraries\mutex;..\..\..\..\..\..\..\..\components\libraries\pwm;..\..\..\..\..\..\..\..\components\libraries\pwr_mgmt;..\..\..\..\..\..\..\..\components\libraries\queue;..\..\..\..\..\..\..\..\components\libraries\ringbuf;..\..\..\..\..\..\..\..\components\libraries\scheduler;..\..\..\..\..\..\..\..\components\libraries\sdcard;..\..\..\..\..\..\..\..\components\libraries\slip;..\..\..\..\..\..\..\..\components\libraries\sortlist;..\..\..\..\..\..\..\..\components\libraries\spi_mngr;..\..\..\..\..\..\..\..\components\libraries\stack_guard;..\..\..\..\..\..\..\..\components\libraries\strerror;..\..\..\..\..\..\..\..\components\libraries\svc;..\..\..\..\..\..\..\..\components\libraries\timer;..\..\..\..\..\..\..\..\components\libraries\twi_mngr;..\..\..\..\..\..\..\..\components\libraries\twi_sensor;..\..\..\..\..\..\..\..\components\libraries\usbd;..\..\..\..\..\..\..\..\components\libraries\usbd\class\audio;..\..\..\..\..\..\..\..\components\libraries\usbd\class\cdc;..\..\..\..\..\..\..\..\components\libraries\usbd\class\cdc\acm;..\..\..\..\..\..\..\..\components\libraries\usbd\class\hid;..\..\..\..\..\..\..\..\components\libraries\usbd\class\hid\generic;..\..\..\..\..\..\..\..\components\libraries\usbd\class\hid\kbd;..\..\..\..\..\..\..\..\components\libraries\usbd\class\hid\mouse;..\..\..\..\..\..\..\..\components\libraries\usbd\class\msc;..\..\..\..\..\..\..\..\components\libraries\util;..\..\..\..\..\..\..\..\components\nfc\ndef\conn_hand_parser;..\..\..\..\..\..\..\..\components\nfc\ndef\conn_hand_parser\ac_rec_parser;..\..\..\..\..\..\..\..\components\nfc\ndef\conn_hand_parser\ble_oob_advdata_parser;..\..\..\..\..\..\..\..\components\nfc\ndef\conn_hand_parser\le_oob_rec_parser;..\..\..\..\..\..\..\..\components\nfc\ndef\connection_handover\ac_rec;..\..\..\..\..\..\..\..\components\nfc\ndef\connection_handover\ble_oob_advdata;..\..\..\..\..\..\..\..\components\nfc\ndef\connection_handover\ble_pair_lib;..\..\..\..\..\..\..\..\components\nfc\ndef\connection_handover\ble_pair_msg;..\..\..\..\..\..\..\..\components\nfc\ndef\connection_handover\common;..\..\..\..\..\..\..\..\components\nfc\ndef\connection_handover\ep_oob_rec;..\..\..\..\..\..\..\..\components\nfc\ndef\connection_handover\hs_rec;..\..\..\..\..\..\..\..\components\nfc\ndef\connection_handover\le_oob_rec;..\..\..\..\..\..\..\..\components\nfc\ndef\generic\message;..\..\..\..\..\..\..\..\components\nfc\ndef\generic\record;..\..\..\..\..\..\..\..\components\nfc\ndef\launchapp;..\..\..\..\..\..\..\..\components\nfc\ndef\parser\message;..\..\..\..\..\..\..\..\components\nfc\ndef\parser\record;..\..\..\..\..\..\..\..\components\nfc\ndef\text;..\..\..\..\..\..\..\..\components\nfc\ndef\uri;..\..\..\..\..\..\..\..\components\nfc\platform;..\..\..\..\..\..\..\..\components\nfc\t2t_lib;..\..\..\..\..\..\..\..\components\nfc\t2t_parser;..\..\..\..\..\..\..\..\components\nfc\t4t_lib;..\..\..\..\..\..\..\..\components\nfc\t4t_parser\apdu;..\..\..\..\..\..\..\..\components\nfc\t4t_parser\cc_file;..\..\..\..\..\..\..\..\components\nfc\t4t_parser\hl_detection_procedure;..\..\..\..\..\..\..\..\components\nfc\t4t_parser\tlv;..\..\..\..\..\..\..\..\components\softdevice\common;..\..\..\..\..\..\..\..\components\softdevice\s132\headers;..\..\..\..\..\..\..\..\components\softdevice\s132\headers\nrf52;..\..\..;..\..\..\..\..\..\..\..\external\fprintf;..\..\..\..\..\..\..\..\external\lwip\src\include;..\..\..\..\..\..\..\..\external\lwip\src\include\lwip;..\..\..\..\..\..\..\..\external\lwip\src\include\netif;..\..\..\..\..\..\..\..\external\lwip\src\port;..\..\..\..\..\..\..\..\external\lwip\src\port\arch;..\..\..\..\..\..\..\..\external\segger_rtt;..\..\..\..\..\..\..\..\external\utf_converter;..\..\..\..\..\..\..\..\integration\nrfx;..\..\..\..\..\..\..\..\integration\nrfx\legacy;..\..\..\..\..\..\..\..\modules\nrfx;..\..\..\..\..\..\..\..\modules\nrfx\drivers\include;..\..\..\..\..\..\..\..\modules\nrfx\hal;..\..\..\..\..\..\..\..\modules\nrfx\mdk;..\config
  asm define: as above
  asm misc: --cpreproc_opts=-DAPP_TIMER_V2,-DAPP_TIMER_V2_RTC1_ENABLED,-DBLE_STACK_SUPPORT_REQD,-DBOARD_PCA10040,-DCONFIG_GPIO_AS_PINRESET,-DFLOAT_ABI_HARD,-DLWIP_DONT_PROVIDE_BYTEORDER_FUNCTIONS,-DNRF52,-DNRF52832_XXAA,-DNRF52_PAN_74,-DNRF_SD_BLE_API_VERSION=7,-DRETARGET_ENABLED=1,-DS132,-DSDK_MUTEX_ENABLE,-DSOFTDEVICE_PRESENT,-D__HEAP_SIZE=0,-D__STACK_SIZE=8192
  asm include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x26000 size 0x5a000
  memory RVCT9: RAM 0x20001f68 size 0xe098
  link misc: --diag_suppress 6330
  group Application
    ../../../: main.c retarget_printf_to_log.c
    ../config/: sdk_config.h
  group Board Definition
    ../../../../../../../../components/boards/: boards.c
  group Board Support
    ../../../../../../../../components/libraries/bsp/: bsp.c
  group UTF8/UTF16 converter
    ../../../../../../../../external/utf_converter/: utf.c
  group lwIP
    ../../../../../../../../external/lwip/src/core/: def.c dhcp.c dns.c inet_chksum.c init.c ip.c memp.c netif.c pbuf.c raw.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    ../../../../../../../../external/lwip/src/core/ipv6/: dhcp6.c icmp6.c inet6.c ip6.c ip6_addr.c mld6.c nd6.c
    ../../../../../../../../external/lwip/src/core/ipv4/: icmp.c ip4.c ip4_addr.c
    ../../../../../../../../external/lwip/src/port/: nrf_platform_port.c
  group nRF_BLE
    ../../../../../../../../components/ble/common/: ble_advdata.c ble_srv_common.c
  group nRF_BLE_Services
    ../../../../../../../../components/ble/ble_services/ble_ipsp/: ble_ipsp.c
  group nRF_Drivers
    ../../../../../../../../integration/nrfx/legacy/: nrf_drv_clock.c nrf_drv_uart.c
    ../../../../../../../../modules/nrfx/soc/: nrfx_atomic.c
    ../../../../../../../../modules/nrfx/drivers/src/: nrfx_clock.c nrfx_gpiote.c nrfx_uart.c nrfx_uarte.c
    ../../../../../../../../modules/nrfx/drivers/src/prs/: nrfx_prs.c
  group nRF_IoT
    ../../../../../../../../components/iot/ble_6lowpan/: ble_6lowpan.c
    ../../../../../../../../components/iot/socket/config/medium/: config_medium.c
    ../../../../../../../../components/iot/errno/: errno.c
    ../../../../../../../../components/iot/socket/libraries/addr_util/: inet_pton.c
    ../../../../../../../../components/iot/context_manager/: iot_context_manager.c
    ../../../../../../../../components/iot/medium/: ipv6_medium_ble.c
    ../../../../../../../../components/iot/ipv6_parse/: ipv6_parse.c
    ../../../../../../../../components/iot/socket/libraries/mbuf/: mbuf.c
    ../../../../../../../../components/iot/socket/libraries/fifo/: nrf_fifo.c
    ../../../../../../../../components/iot/socket/libraries/portdb/: portdb.c
    ../../../../../../../../components/iot/socket/common/: sleep.c socket.c
    ../../../../../../../../components/iot/socket/platform/ble/: socket_ble.c
    ../../../../../../../../components/iot/socket/transport/lwip/: transport_handler.c
  group nRF_Libraries
    ../../../../../../../../components/libraries/button/: app_button.c
    ../../../../../../../../components/libraries/util/: app_error.c app_error_handler_keil.c app_error_weak.c app_util_platform.c nrf_assert.c
    ../../../../../../../../components/libraries/scheduler/: app_scheduler.c
    ../../../../../../../../components/libraries/timer/: app_timer2.c drv_rtc.c
    ../../../../../../../../components/libraries/hardfault/: hardfault_implementation.c
    ../../../../../../../../components/libraries/mem_manager/: mem_manager.c
    ../../../../../../../../components/libraries/atomic_fifo/: nrf_atfifo.c
    ../../../../../../../../components/libraries/atomic/: nrf_atomic.c
    ../../../../../../../../components/libraries/balloc/: nrf_balloc.c
    ../../../../../../../../external/fprintf/: nrf_fprintf.c nrf_fprintf_format.c
    ../../../../../../../../components/libraries/memobj/: nrf_memobj.c
    ../../../../../../../../components/libraries/ringbuf/: nrf_ringbuf.c
    ../../../../../../../../components/libraries/experimental_section_vars/: nrf_section_iter.c
    ../../../../../../../../components/libraries/sortlist/: nrf_sortlist.c
    ../../../../../../../../components/libraries/strerror/: nrf_strerror.c
  group nRF_Log
    ../../../../../../../../components/libraries/log/src/: nrf_log_backend_rtt.c nrf_log_backend_serial.c nrf_log_backend_uart.c nrf_log_default_backends.c nrf_log_frontend.c nrf_log_str_formatter.c
  group nRF_Segger_RTT
    ../../../../../../../../external/segger_rtt/: SEGGER_RTT.c SEGGER_RTT_Syscalls_KEIL.c SEGGER_RTT_printf.c
  group nRF_SoftDevice
    ../../../../../../../../components/softdevice/common/: nrf_sdh.c nrf_sdh_ble.c nrf_sdh_soc.c
target flash_s132_nrf52_7.0.1_softdevice (ARM-ADS)
  device: nRF52832_xxAA Nordic Semiconductor
  pack: ..
  cpu: as above
  output: s132_nrf52_7.0.1_softdevice.hex +hex
  BeforeMake: attrib +R $H\*
  c flags: Optim=4 OneElfS=1 uC99=1
  c define: __HEAP_SIZE=0 __STACK_SIZE=8192
  c misc: --reduce_paths
  c include: ..\..\..\config;..\config
  asm define: __HEAP_SIZE=0 __STACK_SIZE=8192
  asm misc: --cpreproc_opts=-D__HEAP_SIZE=0,-D__STACK_SIZE=8192
  asm include: ..\..\..\config;..\config
  library: MicroLIB
  memory RVCT4: ROM 0x26000 size 0x5a000
  memory RVCT9: RAM 0x20001f68 size 0xe098
  link misc: --diag_suppress 6330
software components: CMSIS:CORE 4.3.0, Device:Startup 8.27.0

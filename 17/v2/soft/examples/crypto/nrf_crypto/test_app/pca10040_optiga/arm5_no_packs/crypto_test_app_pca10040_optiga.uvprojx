# Keil uVision project crypto_test_app_pca10040_optiga.uvprojx, settings and files
target nrf52832_xxaa (ARM-ADS)
  device: nRF52832_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack_NordicLicense.8.27.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(64000000) ELITTLE
  output: nrf52832_xxaa +hex
  c flags: Optim=4 OneElfS=1 uC99=1
  c define: APP_TIMER_V2 APP_TIMER_V2_RTC1_ENABLED BOARD_PCA10040 BSP_DEFINES_ONLY CONFIG_GPIO_AS_PINRESET DL_MAX_FRAME_SIZE=250 FLOAT_ABI_HARD NRF52 NRF52832_XXAA NRF52_PAN_74 __HEAP_SIZE=8192 __STACK_SIZE=16384
  c misc: --reduce_paths
  c include: ..\..\config;..\..\..\..\..\..\components;..\..\..\..\..\..\components\boards;..\..\..\..\..\..\components\drivers_nrf\nrf_soc_nosd;..\..\..\..\..\..\components\libraries\atomic;..\..\..\..\..\..\components\libraries\atomic_fifo;..\..\..\..\..\..\components\libraries\balloc;..\..\..\..\..\..\components\libraries\bsp;..\..\..\..\..\..\components\libraries\crypto;..\..\..\..\..\..\components\libraries\crypto\backend\cc310;..\..\..\..\..\..\components\libraries\crypto\backend\cc310_bl;..\..\..\..\..\..\components\libraries\crypto\backend\cifra;..\..\..\..\..\..\components\libraries\crypto\backend\mbedtls;..\..\..\..\..\..\components\libraries\crypto\backend\micro_ecc;..\..\..\..\..\..\components\libraries\crypto\backend\nrf_hw;..\..\..\..\..\..\components\libraries\crypto\backend\nrf_sw;..\..\..\..\..\..\components\libraries\crypto\backend\oberon;..\..\..\..\..\..\components\libraries\crypto\backend\optiga;..\..\..\..\..\..\components\libraries\delay;..\..\..\..\..\..\components\libraries\experimental_section_vars;..\..\..\..\..\..\components\libraries\log;..\..\..\..\..\..\components\libraries\log\src;..\..\..\..\..\..\components\libraries\mem_manager;..\..\..\..\..\..\components\libraries\memobj;..\..\..\..\..\..\components\libraries\mutex;..\..\..\..\..\..\components\libraries\pwr_mgmt;..\..\..\..\..\..\components\libraries\queue;..\..\..\..\..\..\components\libraries\ringbuf;..\..\..\..\..\..\components\libraries\scheduler;..\..\..\..\..\..\components\libraries\sortlist;..\..\..\..\..\..\components\libraries\stack_info;..\..\..\..\..\..\components\libraries\strerror;..\..\..\..\..\..\components\libraries\timer;..\..\..\..\..\..\components\libraries\twi_mngr;..\..\..\..\..\..\components\libraries\util;..\..;..\..\common_test;..\..\test_cases;..\..\..\..\..\..\external\fprintf;..\..\..\..\..\..\external\infineon\examples\ecdsa_utils;..\..\..\..\..\..\external\infineon\optiga\include;..\..\..\..\..\..\external\nrf_oberon;..\..\..\..\..\..\external\nrf_oberon\include;..\..\..\..\..\..\external\segger_rtt;..\..\..\..\..\..\integration\nrfx;..\..\..\..\..\..\integration\nrfx\legacy;..\..\..\..\..\..\modules\nrfx;..\..\..\..\..\..\modules\nrfx\drivers\include;..\..\..\..\..\..\modules\nrfx\hal;..\..\..\..\..\..\modules\nrfx\mdk;..\config
  asm define: as above
  asm misc: --cpreproc_opts=-DAPP_TIMER_V2,-DAPP_TIMER_V2_RTC1_ENABLED,-DBOARD_PCA10040,-DBSP_DEFINES_ONLY,-DCONFIG_GPIO_AS_PINRESET,-DDL_MAX_FRAME_SIZE=250,-DFLOAT_ABI_HARD,-DNRF52,-DNRF52832_XXAA,-DNRF52_PAN_74,-D__HEAP_SIZE=8192,-D__STACK_SIZE=16384
  asm include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  link misc: --diag_suppress 6330
  group Application
    ../../common_test/: common_test.c
    ../../: main.c
    ../config/: sdk_config.h
  group Board Definition
    ../../../../../../components/boards/: boards.c
  group Infineon
    ../../../../../../external/infineon/optiga/cmd/: CommandLib.c
    ../../../../../../external/infineon/optiga/common/: Logger.c Util.c
    ../../../../../../external/infineon/examples/ecdsa_utils/: ecdsa_utils.c
    ../../../../../../external/infineon/optiga/comms/ifx_i2c/: ifx_i2c.c ifx_i2c_config.c ifx_i2c_data_link_layer.c ifx_i2c_physical_layer.c ifx_i2c_transport_layer.c
    ../../../../../../external/infineon/optiga/comms/: optiga_comms.c
    ../../../../../../external/infineon/optiga/crypt/: optiga_crypt.c
    ../../../../../../external/infineon/optiga/util/: optiga_util.c
    ../../../../../../external/infineon/pal/nrf5x/: pal_gpio.c pal_i2c.c pal_ifx_i2c_config.c pal_os.c pal_os_lock.c
  group Test Cases
    ../../test_cases/: test_ecdsa.c test_vectors_ecdsa_random.c test_vectors_ecdsa_sign.c test_vectors_ecdsa_verify.c
  group nRF_Crypto
    ../../../../../../components/libraries/crypto/: nrf_crypto_aead.c nrf_crypto_aes.c nrf_crypto_aes_shared.c nrf_crypto_ecc.c nrf_crypto_ecdh.c nrf_crypto_ecdsa.c nrf_crypto_eddsa.c nrf_crypto_error.c nrf_crypto_hash.c nrf_crypto_hkdf.c nrf_crypto_hmac.c nrf_crypto_init.c nrf_crypto_rng.c nrf_crypto_shared.c
  group nRF_Crypto backend Oberon
    ../../../../../../components/libraries/crypto/backend/oberon/: oberon_backend_chacha_poly_aead.c oberon_backend_ecc.c oberon_backend_ecdh.c oberon_backend_ecdsa.c oberon_backend_eddsa.c oberon_backend_hash.c oberon_backend_hmac.c
  group nRF_Crypto backend Optiga
    ../../../../../../components/libraries/crypto/backend/optiga/: optiga_backend_ecc.c optiga_backend_ecdh.c optiga_backend_ecdsa.c optiga_backend_init.c optiga_backend_rng.c
  group nRF_Drivers
    ../../../../../../integration/nrfx/legacy/: nrf_drv_clock.c nrf_drv_twi.c
    ../../../../../../components/drivers_nrf/nrf_soc_nosd/: nrf_nvic.c nrf_soc.c
    ../../../../../../modules/nrfx/soc/: nrfx_atomic.c
    ../../../../../../modules/nrfx/drivers/src/: nrfx_clock.c nrfx_rtc.c nrfx_twi.c nrfx_twim.c
    ../../../../../../modules/nrfx/drivers/src/prs/: nrfx_prs.c
  group nRF_Libraries
    ../../../../../../components/libraries/util/: app_error.c app_error_handler_keil.c app_error_weak.c app_util_platform.c nrf_assert.c
    ../../../../../../components/libraries/scheduler/: app_scheduler.c
    ../../../../../../components/libraries/timer/: app_timer2.c drv_rtc.c
    ../../../../../../components/libraries/mem_manager/: mem_manager.c
    ../../../../../../components/libraries/atomic_fifo/: nrf_atfifo.c
    ../../../../../../components/libraries/atomic/: nrf_atomic.c
    ../../../../../../components/libraries/balloc/: nrf_balloc.c
    ../../../../../../external/fprintf/: nrf_fprintf.c nrf_fprintf_format.c
    ../../../../../../components/libraries/memobj/: nrf_memobj.c
    ../../../../../../components/libraries/pwr_mgmt/: nrf_pwr_mgmt.c
    ../../../../../../components/libraries/queue/: nrf_queue.c
    ../../../../../../components/libraries/ringbuf/: nrf_ringbuf.c
    ../../../../../../components/libraries/experimental_section_vars/: nrf_section_iter.c
    ../../../../../../components/libraries/sortlist/: nrf_sortlist.c
    ../../../../../../components/libraries/strerror/: nrf_strerror.c
    ../../../../../../components/libraries/twi_mngr/: nrf_twi_mngr.c
  group nRF_Log
    ../../../../../../components/libraries/log/src/: nrf_log_backend_rtt.c nrf_log_backend_serial.c nrf_log_default_backends.c nrf_log_frontend.c nrf_log_str_formatter.c
  group nRF_Oberon_Crypto
    ../../../../../../external/nrf_oberon/lib/cortex-m4/hard-float/short-wchar/: oberon_3.0.1.lib
  group nRF_Segger_RTT
    ../../../../../../external/segger_rtt/: SEGGER_RTT.c SEGGER_RTT_Syscalls_KEIL.c SEGGER_RTT_printf.c
software components: CMSIS:CORE 4.3.0, Device:Startup 8.27.0

# Keil uVision project bluetooth_keypad.uvproj, settings and files
target nrf52810qc (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: nRF52810_xxAA Nordic Semiconductor
  cpu: IRAM(0x20000000-0x20005FFF) IROM(0-0x2FFFF) CLOCK(64000000) CPUTYPE("Cortex-M4") ESEL ELITTLE
  output: bluetooth_keypad +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: APP_TIMER_V2 APP_TIMER_V2_RTC1_ENABLED BOARD_PCA10040 CONFIG_GPIO_AS_PINRESET NRF_LOG_USES_RTT=1 FLOAT_ABI_SOFT NRF52810_XXAA NRF52_PAN_74 NRFX_COREDEP_DELAY_US_LOOP_CYCLES=3 NRF_SD_BLE_API_VERSION=7 S112 SOFTDEVICE_PRESENT __HEAP_SIZE=2048 __STACK_SIZE=2048
  c misc: --c99 --reduce_paths
  c include: ..\source;..\lib\bsp;..\lib\nrfx;..\lib\ringbuf;..\lib\scheduler;..\lib\timer;..\lib\nrfx\hal;..\lib\nrfx\drivers\include;..\lib\softdevice;..\lib\softdevice\s112\headers;..\lib\log;..\lib\segger_rtt;..\lib\util;..\lib\nrf_soc_nosd;..\lib\nrfx\mdk;..\lib\experimental_section_vars;..\lib\fprintf;..\lib\atomic;..\lib\atomic_fifo;..\lib\atomic_flags;..\lib\delay;..\lib\strerror;..\lib\memobj;..\lib\sortlist;..\lib\balloc;..\lib\ble\common;..\lib\ble\ble_advertising;..\lib\ble\nrf_ble_gatt;..\lib\ble\nrf_ble_qwr;..\lib\ble\nrf_ble_scan;..\lib\ble\peer_manager;..\lib\fds;..\lib\button;..\lib\ble\ble_link_ctx_manager;..\lib\fstorage;..\lib\mutex;..\lib\queue;..\lib\ble\ble_services\ble_hids;..\lib\ble\ble_services\ble_bas;..\lib\ble\ble_services\ble_dis;..\lib\pwr_mgmt
  asm define: APP_TIMER_V2 APP_TIMER_V2_RTC1_ENABLED BOARD_PCA10040 CONFIG_GPIO_AS_PINRESET DEVELOP_IN_NRF52832 FLOAT_ABI_SOFT NRF52810_XXAA NRF52_PAN_74 NRFX_COREDEP_DELAY_US_LOOP_CYCLES=3 NRF_SD_BLE_API_VERSION=7 S112 SOFTDEVICE_PRESENT __HEAP_SIZE=2048 __STACK_SIZE=2048
  asm misc: --cpreproc_opts=-DAPP_TIMER_V2,-DAPP_TIMER_V2_RTC1_ENABLED,-DBOARD_PCA10040,-DCONFIG_GPIO_AS_PINRESET,-DDEVELOP_IN_NRF52832,-DFLOAT_ABI_SOFT,-DNRF52810_XXAA,-DNRF52_PAN_74,-DNRFX_COREDEP_DELAY_US_LOOP_CYCLES=3,-DNRF_SD_BLE_API_VERSION=7,-DS112,-DSOFTDEVICE_PRESENT,-D__HEAP_SIZE=2048,-D__STACK_SIZE=2048
  library: MicroLIB
  memory RVCT4: ROM 0x19000 size 0x17000
  memory RVCT9: RAM 0x20001a40 size 0x45c0
  link misc: --diag_suppress 6330
  group Board
    ../lib/bsp/: boards.c bsp.c
    ../lib/nrfx/mdk/: arm_startup_nrf52810.s system_nrf52810.c
  group Application
    ../source/: main.c i2c.c keys.c leds.c mole.c rgb.c
  group BLE
    ../lib/ble/ble_advertising/: ble_advertising.c
    ../lib/ble/ble_link_ctx_manager/: ble_link_ctx_manager.c
    ../lib/ble/ble_services/ble_bas/: ble_bas.c
    ../lib/ble/ble_services/ble_dis/: ble_dis.c
    ../lib/ble/ble_services/ble_hids/: ble_hids.c
    ../lib/ble/common/: ble_conn_params.c ble_conn_state.c ble_srv_common.c ble_advdata.c
    ../lib/ble/nrf_ble_gatt/: nrf_ble_gatt.c
    ../lib/ble/nrf_ble_qwr/: nrf_ble_qwr.c
    ../lib/ble/peer_manager/: peer_data_storage.c peer_database.c peer_id.c peer_manager.c peer_manager_handler.c pm_buffer.c security_dispatcher.c security_manager.c gatt_cache_manager.c gatts_cache_manager.c auth_status_tracker.c id_manager.c
  group Drivers
    ../lib/nrfx/drivers/src/: nrfx_clock.c nrfx_gpiote.c nrfx_twi.c nrfx_twim.c nrfx_saadc.c nrfx_rng.c nrfx_timer.c nrf_drv_rng.c
    ../lib/atomic/: nrf_atomic.c
    ../lib/nrfx/drivers/src/prs/: nrfx_prs.c
  group Libraries
    ../lib/ringbuf/: nrf_ringbuf.c
    ../lib/scheduler/: app_scheduler.c
    ../lib/timer/: app_timer2.c drv_rtc.c
    ../lib/button/: app_button.c
    ../lib/util/: app_error.c app_error_handler_keil.c app_error_weak.c app_util_platform.c nrf_assert.c
    ../lib/atomic_fifo/: nrf_atfifo.c
    ../lib/atomic_flags/: nrf_atflags.c
    ../lib/balloc/: nrf_balloc.c
    ../lib/fprintf/: nrf_fprintf_format.c nrf_fprintf.c
    ../lib/fds/: fds.c
    ../lib/memobj/: nrf_memobj.c
    ../lib/experimental_section_vars/: nrf_section_iter.c
    ../lib/sortlist/: nrf_sortlist.c
    ../lib/strerror/: nrf_strerror.c
    ../lib/fstorage/: nrf_fstorage.c nrf_fstorage_sd.c
    ../lib/log/src/: nrf_log_backend_serial.c
    ../lib/queue/: nrf_queue.c
    ../lib/pwr_mgmt/: nrf_pwr_mgmt.c
  group nRF_Log
    ../lib/log/src/: nrf_log_backend_rtt.c nrf_log_default_backends.c nrf_log_frontend.c nrf_log_str_formatter.c
  group Segger_RTT
    ../lib/segger_rtt/: SEGGER_RTT.c SEGGER_RTT_Syscalls_KEIL.c SEGGER_RTT_printf.c
  group SoftDevice
    ../lib/softdevice/: nrf_sdh.c nrf_sdh_ble.c nrf_sdh_soc.c

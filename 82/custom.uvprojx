# Keil uVision project custom.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: custom +hex
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: .\System\STM32_USB-FS-Device_Driver\inc;.\System\STM32F10x_FWLib\inc;.\Core;.\System;.\Driver\USB;.\Driver\LED;.\Driver\delay;.\Driver\key;.\System\sys;.\Driver\AIP1638;.\Application
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application
    ./Application/: main.cpp keyboard.cpp
  group USB
    ./System/STM32_USB-FS-Device_Driver/src/: usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c usb_sil.c
    ./Driver/USB/: hw_config.c usb_desc.c usb_endp.c usb_istr.c usb_prop.c usb_pwr.c usb.c
  group Firmware
    ./System/: stm32f10x_it.c
    ./System/STM32F10x_FWLib/src/: misc.c stm32f10x_exti.c stm32f10x_gpio.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c
  group Core
    ./Core/: core_cm3.c
  group Driver
    ./Driver/LED/: led.c
    ./Driver/AIP1638/: aip1638.c
    ./Driver/key/: key.c
    ./Driver/delay/: delay.c
software components: CMSIS:CORE 5.3.0, Compiler:I/O:STDERR 1.2.0, Compiler:I/O:STDIN 1.2.0, Compiler:I/O:STDOUT 1.2.0, Compiler:I/O:TTY 1.2.0, Device:GPIO 1.3, Device:Startup 1.0.0

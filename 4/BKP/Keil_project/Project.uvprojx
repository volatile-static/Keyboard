# Keil uVision project Project.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: GD32F103C8 GigaDevice
  pack: GigaDevice.GD32F10x_DFP.2.0.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: 1
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\..\Desktop;D:\STM32\GD32F10x_Firmware_Library_V2.1.0\Firmware\CMSIS\GD\GD32F10x\Include;D:\STM32\GD32F10x_Firmware_Library_V2.1.0\Firmware\CMSIS;D:\STM32\GD32F10x_Firmware_Library_V2.1.0\Firmware\GD32F10x_standard_peripheral\Include
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Source Group 1
    ../: gd32f10x_it.c main.c systick.c core_cm3.c sys.c
    D:/STM32/GD32F10x_Firmware_Library_V2.1.0/Firmware/CMSIS/GD/GD32F10x/Source/: system_gd32f10x.c
    D:/STM32/GD32F10x_Firmware_Library_V2.1.0/Firmware/CMSIS/GD/GD32F10x/Source/ARM/: startup_gd32f10x_md.s
    D:/STM32/GD32F10x_Firmware_Library_V2.1.0/Firmware/GD32F10x_standard_peripheral/Source/: gd32f10x_dbg.c gd32f10x_exti.c gd32f10x_gpio.c gd32f10x_spi.c gd32f10x_timer.c gd32f10x_rcu.c

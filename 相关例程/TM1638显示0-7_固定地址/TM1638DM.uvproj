# Keil uVision project TM1638DM.uvproj, settings and files
target TM1638DM (MCS-51)
  device: AT89S52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(33000000) MODAT2
  output: TM1638DM +hex
  c flags: Optimize=8 SizeSpeed=1
  group Application File
    ./: TM1638.C
